Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], ExchangeRequirement []
File name: Número de proyecto
Time: 2022-04-29T12:01:05
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 22.0.1.367 - Exporter 22.0.1.367 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Apr 29 12:01:05 2022 * Host: DESKTOP-PKHS3E7 * Database: C:\Users\arull\AppData\Local\Temp\87e69232-5d05-4509-840c-a33159a15714\d5eda1eb-52f6-4ab3-a93f-bfaacbb4d7ee\ifc * Database version: 5507 * Database creation date: Fri Apr 29 12:00:59 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Apr 29 12:00:59 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Apr 29 12:00:59 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Número de proyecto
LongName: Nombre de proyecto; Phase: Estado de proyecto

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Otros - Categoría: Información de proyecto; Dirección de proyecto: ## Calle Ciudad, Estado CP; Estado de proyecto: Estado de proyecto; Fecha de emisión de proyecto: Fecha de emisión; Nombre de cliente: Propietario; Nombre de proyecto: Nombre de proyecto; Número de proyecto: Número de proyecto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Otros - Categoría: Información de proyecto; Dirección de proyecto: ## Calle Ciudad, Estado CP; Estado de proyecto: Estado de proyecto; Fecha de emisión de proyecto: Fecha de emisión; Nombre de cliente: Propietario; Nombre de proyecto: Nombre de proyecto; Número de proyecto: Número de proyecto

# IfcBuildingStorey: Nivel:Extremo inicial 8 mm, Nivel 1
LongName: Nivel 1; Elevation: 0 mm
Restricciones(Type) - Base de elevación: Punto base del proyecto
Cotas - Altura de cálculo: 0 mm
Datos de identidad - Estructura: no; Nombre: Nivel 1; Planta de edificio: yes
Otros - Categoría: Niveles; Familia: Nivel: Extremo inicial 8 mm; Familia y tipo: Nivel: Extremo inicial 8 mm; ID de tipo: Nivel: Extremo inicial 8 mm; Tipo: Nivel: Extremo inicial 8 mm
Restricciones - Alzado: 0 mm
Datos de identidad(Type) - Nombre de tipo: Extremo inicial 8 mm
Gráficos(Type) - Color: 0; Grosor de línea: 1; Patrón de línea: Centro 1; Símbolo: M_Extremo inicial de nivel - Círculo: M_Extremo inicial de nivel - Círculo; Símbolo en extremo 1 por defecto: no; Símbolo en extremo 2 por defecto: yes
Otros(Type) - Categoría: Niveles; Nombre de familia: Nivel

# IfcBuildingElementProxy: Familia1:Norma, Familia1:Norma:211129
In: Nivel 1
Type - Material: Acero
Type - Datos de identidad - Nombre de tipo: Norma
Type - Otros - Categoría: Modelos genéricos; Nombre de familia: Familia1
Type - Restricciones - Elevación por defecto: 0 mm
Pset_BuildingElementProxyCommon - Reference: Norma; sets with these values: 2
Cotas - Área: 0.00188647 m2; Volumen: 0.0000101876 m3
Otros - Familia: Familia1: Norma; Familia y tipo: Familia1: Norma; ID de tipo: Familia1: Norma; Tipo: Familia1: Norma
Proceso por fases - Fase de creación: Nueva construcción
Restricciones - Anfitrión: Ninguno; Desfase desde el anfitrión: 0 mm; Elevación desde el nivel: 0 mm; Se mueve con elementos cercanos: no
